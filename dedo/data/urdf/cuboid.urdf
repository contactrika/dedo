Commit message: Added support for Button, Dress, Hoop, Lasso; Added support for env versions

File: dedo/data/urdf/cuboid.urdf (robot description, URDF)
Before this commit: robot cuboid, 2 links, 1 joints
Links:
- link cuboid: geometry collision box size=0.2 0.3 0.5; visual box size=0.2 0.3 0.5
