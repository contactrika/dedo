Commit message: Got hanging to work

File: dedo/data/simple/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- removed link cube_base_link
- added link baseLink, mass 1.0; collision box size=1 1 1; visual mesh filename=cube.obj scale=1 1 1
